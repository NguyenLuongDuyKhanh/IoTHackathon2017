# Keil uVision project SmartGo.uvprojx, settings and files
target SmartGo (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartGo
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\SourceCode\CMSIS\CoreSupport;.\SourceCode\CMSIS\DeviceSupport\ST\STM32F10x;.\SourceCode\Startup;.\SourceCode\StdPeriph\inc;.\SourceCode\User\Inc;.\SourceCode\StdPeriph
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./SourceCode/CMSIS/CoreSupport/: core_cm3.c
    ./SourceCode/CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ./SourceCode/User/Src/: delay.c DirectionData.c UART_Driver.c main.c SSD1306.c
  group StdPeriph
    ./SourceCode/StdPeriph/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ./SourceCode/Startup/: startup_stm32f10x_md.s
